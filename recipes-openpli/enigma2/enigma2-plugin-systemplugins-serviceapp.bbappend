CXXFLAGS_append_cube += " -std=c++11 -fPIC -fno-strict-aliasing "
